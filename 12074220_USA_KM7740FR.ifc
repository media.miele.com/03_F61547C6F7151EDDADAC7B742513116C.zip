Properties of the parts of a building model (IFC2X3)

# File
Description: ViewDefinition [COBie2.4DesignDeliverable]
File name: 0001
Time: 2023-02-21T08:53:20
Written by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013
Made in: 21.1.21.45 - Exporter 21.1.21.45 - Default UI
Comment: STEP Physical File produced by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013 * Module: EDMstepFileFactory/EDMstandAlone * Creation date: Tue Feb 21 08:53:20 2023 * Host: DEGTW9512 * Database: C:\Users\deschvi\AppData\Local\Temp\1ffc098b-0b08-429e-8813-d38779899f2a\0801c1db-fd3c-40b7-816b-adf95d602ae8\ifc * Database version: 5507 * Database creation date: Tue Feb 21 08:53:19 2023 * Schema: IFC2X3 * Model: DataRepository.ifc * Model creation date: Tue Feb 21 08:53:19 2023 * Header model: DataRepository.ifc_HeaderModel * Header model creation date: Tue Feb 21 08:53:19 2023 * EDMuser: sdai-user * EDMgroup: sdai-group * License ID and type: 5605 : Permanent license. Expiry date: * EDMstepFileFactory options: 020000

# IfcProject, 0001
LongName: Project Name; Phase: Project Status

# IfcSite, Default
RefLatitude: 42, 21, 31, 181945; RefLongitude: -71, -3, -24, -263305; RefElevation: 0 mm
Pset_ProductRequirements - Category: Project Information

# IfcBuildingElementProxy: 12074220_USA_KM7740FR:26774000_USA_12074220_KM7740FR, (2)
In: Default
Type - Material: z_Miele_Design_Glass Black, z_Miele_Connection_Electric, z_Miele_Design_CLST
Type - Pset_BuildingElementProxyCommon - Reference: 26774000_USA_12074220_KM7740FR
Type - Pset_ManufacturerTypeInformation - Manufacturer: Miele
Type - Pset_ProductRequirements - Category: Specialty Equipment
Type - Pset_QuantityTakeOff - Reference: 26774000_USA_12074220_KM7740FR
Type - Pset_ProvisionForVoid - Width: 915 mm; Height: 78 mm; Depth: 544 mm
Pset_BuildingElementProxyCommon - sets with these values: 2
